## base_external/configs/aesd_qemu_defconfig
```kconfig
BR2_ROOTFS_OVERLAY="../base_external/rootfs_overlay"
BR2_PACKAGE_HOST_KMOD=y
BR2_PACKAGE_AESD_ASSIGNMENTS=y
```
